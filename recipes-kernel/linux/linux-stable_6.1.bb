# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "1"
LINUX_VPATCH = "98"
LINUX_SHA256_TARBALL = "2ca1f17051a430f6fed1196e4952717507171acfd97d96577212502703b25deb"
LINUX_SHA256_PATCH = "c2b1b2b9e89f627f664c25ac1ee30b09b48e32c8b6e47b9c6f84e9dafc7e72b1"
require linux-stable.inc
