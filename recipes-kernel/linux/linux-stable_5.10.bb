# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "10"
LINUX_VPATCH = "220"
LINUX_SHA256_TARBALL = "dcdf99e43e98330d925016985bfbc7b83c66d367b714b2de0cbbfcbf83d8ca43"
LINUX_SHA256_PATCH = "65146ed724b9ea3763116e2fe653a5f1171e64358e6a9d315fe4fa8e5b52baf2"
require linux-stable.inc
