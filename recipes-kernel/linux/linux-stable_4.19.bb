# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "4"
LINUX_VMINOR = "19"
LINUX_VPATCH = "318"
LINUX_SHA256_TARBALL = "0c68f5655528aed4f99dae71a5b259edc93239fa899e2df79c055275c21749a1"
LINUX_SHA256_PATCH = "f77936465de7cacb28e1c22b3ac79d40fbda55c6fa54ea5cd5b7187e6f2278e8"
require linux-stable.inc
