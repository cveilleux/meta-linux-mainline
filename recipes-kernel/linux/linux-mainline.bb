# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VERSION = "6.9-rc7"
SRCREV = "dd5a440a31fae6e459c0d6271dddd62825505361"
require linux-mainline.inc
