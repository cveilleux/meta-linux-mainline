# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "6"
LINUX_VPATCH = "36"
LINUX_SHA256_TARBALL = "d926a06c63dd8ac7df3f86ee1ffc2ce2a3b81a2d168484e76b5b389aba8e56d0"
LINUX_SHA256_PATCH = "4164fe7b3e2fdbf71703afcb9216d2a1f09d45e27cbe04dd33a93492ca80299d"
require linux-stable.inc
