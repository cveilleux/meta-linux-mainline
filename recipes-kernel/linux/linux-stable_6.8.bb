# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "8"
LINUX_VPATCH = "6"
LINUX_SHA256_TARBALL = "c969dea4e8bb6be991bbf7c010ba0e0a5643a3a8d8fb0a2aaa053406f1e965f3"
LINUX_SHA256_PATCH = "d8b22b28a75e6d959aff2eb8ce38261b9b5f88f15d53686c939fe404083ba8a0"
require linux-stable.inc
