# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "4"
LINUX_VPATCH = "15"
LINUX_SHA256_TARBALL = "8fa0588f0c2ceca44cac77a0e39ba48c9f00a6b9dc69761c02a5d3efac8da7f3"
LINUX_SHA256_PATCH = "1ca886eb7115549321c3869d8fe37fda32b1918ddfbb80be000cd265937b28fa"
require linux-stable.inc
