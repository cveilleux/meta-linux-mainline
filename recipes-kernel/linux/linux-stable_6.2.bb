# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "2"
LINUX_VPATCH = "11"
LINUX_SHA256_TARBALL = "74862fa8ab40edae85bb3385c0b71fe103288bce518526d63197800b3cbdecb1"
LINUX_SHA256_PATCH = "923cbd9f2120a7972a45cfdfcfd1871f76735de36cee2630d10a6a3d5c845149"
require linux-stable.inc
