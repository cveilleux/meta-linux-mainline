# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "4"
LINUX_VPATCH = "280"
LINUX_SHA256_TARBALL = "bf338980b1670bca287f9994b7441c2361907635879169c64ae78364efc5f491"
LINUX_SHA256_PATCH = "c7cad8dd554d02d80161270a89811fb35fba6b3bba3566cce8bde3144e0782dd"
require linux-stable.inc
