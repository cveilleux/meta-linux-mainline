# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "5"
LINUX_VPATCH = "4"
LINUX_SHA256_TARBALL = "7a574bbc20802ea76b52ca7faf07267f72045e861b18915c5272a98c27abf884"
LINUX_SHA256_PATCH = "14e8569a800595a7bf22d005fbaf72b70f81b86346be27fc9bfaa14c78480f8e"
require linux-stable.inc
