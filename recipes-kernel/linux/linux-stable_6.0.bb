# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "0"
LINUX_VPATCH = "9"
LINUX_SHA256_TARBALL = "5c2443a5538de52688efb55c27ab0539c1f5eb58c0cfd16a2b9fbb08fd81788e"
LINUX_SHA256_PATCH = "dc5704014e53dd661f78fd062facc3518242d3412bef6b9bea69089f53f10a78"
require linux-stable.inc
