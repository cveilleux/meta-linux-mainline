# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "9"
LINUX_VPATCH = "9"
LINUX_SHA256_TARBALL = "24fa01fb989c7a3e28453f117799168713766e119c5381dac30115f18f268149"
LINUX_SHA256_PATCH = "0a988fea75294155d7e44505e95bd6c56304d5650b6910fc5e50847ae16e77e7"
require linux-stable.inc
