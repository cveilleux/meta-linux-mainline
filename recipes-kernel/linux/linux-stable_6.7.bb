# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "6"
LINUX_VMINOR = "7"
LINUX_VPATCH = "4"
LINUX_SHA256_TARBALL = "ef31144a2576d080d8c31698e83ec9f66bf97c677fa2aaf0d5bbb9f3345b1069"
LINUX_SHA256_PATCH = "73f653c38fcbdc5bb3e3d30facb0a1fc8659f41d2fe23b263fcc52de03246d83"
require linux-stable.inc
