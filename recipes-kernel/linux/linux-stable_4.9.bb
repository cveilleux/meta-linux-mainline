# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "4"
LINUX_VMINOR = "9"
LINUX_VPATCH = "326"
LINUX_SHA256_TARBALL = "029098dcffab74875e086ae970e3828456838da6e0ba22ce3f64ef764f3d7f1a"
LINUX_SHA256_PATCH = "15ff87e7ec5f362f13400d519da90605c7f5ca1c74e27c32e18eb3fc8f90f13f"
require linux-stable.inc
