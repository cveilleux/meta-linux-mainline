# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "4"
LINUX_VMINOR = "14"
LINUX_VPATCH = "304"
LINUX_SHA256_TARBALL = "f81d59477e90a130857ce18dc02f4fbe5725854911db1e7ba770c7cd350f96a7"
LINUX_SHA256_PATCH = "cf52b30c24ca72b567e875f58a36a0af1bd3a340f45042ad2f39164805f8e42f"
require linux-stable.inc
