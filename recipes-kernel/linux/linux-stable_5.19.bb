# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "19"
LINUX_VPATCH = "1"
LINUX_SHA256_TARBALL = "ff240c579b9ee1affc318917de07394fc1c3bb49dac25ec1287370c2e15005a8"
LINUX_SHA256_PATCH = "e3b9167a3286441f843220bc3339f7bafc256ec4e7b5a080badca6ce8b6c7926"
require linux-stable.inc
