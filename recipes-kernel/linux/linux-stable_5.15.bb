# Copyright (C) 2021, meta-linux-mainline contributors (auto-generated file)
# SPDX-License-Identifier: CC0-1.0
LINUX_VMAJOR = "5"
LINUX_VMINOR = "15"
LINUX_VPATCH = "155"
LINUX_SHA256_TARBALL = "57b2cf6991910e3b67a1b3490022e8a0674b6965c74c12da1e99d138d1991ee8"
LINUX_SHA256_PATCH = "d779724fbe4a707c9e7434039660a2455f82cb4a065d24eeb73d99323d500c71"
require linux-stable.inc
